# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\24cxx;..\SYSTEM\iic;..\SYSTEM\mod;..\SYSTEM\readconfig;..\SYSTEM\rtc;..\SYSTEM\sim800;..\SYSTEM\timer;..\SYSTEM\usart2;..\SYSTEM\usart3;..\SYSTEM\send;..\SYSTEM\device;..\SYSTEM\systick;..\SYSTEM\Common
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/sim800/: SIM800.c
    ../SYSTEM/send/: send.c
    ../SYSTEM/device/: device.c
    ../SYSTEM/systick/: SysTick.c
    ../SYSTEM/usart2/: usart2.c
    ../SYSTEM/usart3/: usart3.c
    ../SYSTEM/timer/: timer.c
    ../SYSTEM/mod/: mod.c usart_mod.c
    ../SYSTEM/rtc/: rtc.c
    ../SYSTEM/readconfig/: readconfig.c
    ../SYSTEM/Common/: Common.c
    ../SYSTEM/iic/: iic.c
    ./: mycc.c ff.h integer.h ffconf.h fontupd.h
